Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 換皂罐式一對多示意圖202002.IFC
Time: 2022-01-04T08:18:47
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2.5公升皂罐
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0090_快速L型球閥 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 供皂系統_5公升皂罐_20191001
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 排氣PE管
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 皂液蓋_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 皂液蓋橡膠02
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 皂管接管8
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 皂罐托架_20191023 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
