Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-CSDTM_供皂系統組合件_20220104.IFC
Time: 2022-01-04T08:10:50
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2.0_90度端子座 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0130-0086_檯面固定塑件
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0087_檯面加皂口蓋塑件_201810
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0130-0088檯面塑件螺帽
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0090_快速L型球閥
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0122_HK-CSDTM_檯面皂罐填充組_11_20191027
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0130-0122_HK-CSDTM_檯面皂罐填充組_20191027 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0130-0143_HK-CSDTM_皂口連接管
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0330-0011_檯面皂罐固定座
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0330-0012_檯面皂罐固定下座
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0330-0013_檯面飾框
In: Default Storey
PredefinedType: ELEMENT; Material: AISI 316不鏽鋼板 (SS)

# IfcBuildingElementProxy: C0335-0003_Auto Tap SUS示板
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: DC電源插座
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: F0230-0007_一對多LED機板
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: G0108-0023_O環S39_矽膠
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: G0130-0029_檯面固定橡膠
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: G0130-0038_HK-CSDTM_6公升皂罐橡膠
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 一對多系統PCB_20180430
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 吸盤30mm
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 填料-伸長4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 手轉螺絲4M_6mm (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 檯面零件
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 水位偵測控制盒上蓋-20180608
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位偵測控制盒下蓋_20180608
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關01-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關01-10
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關01-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關01-3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關01-4
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關3
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關4
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 水位開關5
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 除料-旋轉1[2]
In: Default Storey
PredefinedType: ELEMENT
